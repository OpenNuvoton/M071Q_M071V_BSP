# IAR project USBD_CCID.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: M071Q_V series Nuvoton M071Q/M071V series
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDiagSuppress: Pa082
  ICCARM.CCIncludePath2: ..\..\..\..\Library\Device\Nuvoton\M071Q_M071V\Include; ..\..\..\..\Library\CMSIS\Include; ..\..\..\..\Library\StdDriver\inc; ..\..\..\..\Library\SmartcardLib\Include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: USBD_CCID.bin
  ILINK.IlinkOutputFile: USBD_CCID.out
  ILINK.IlinkIcfFile: USBD_CCID.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
  group CMSIS
    ../../../../Library/Device/Nuvoton/M071Q_M071V/Source/IAR/: startup_M071Q_M071V.s
    ../../../../Library/Device/Nuvoton/M071Q_M071V/Source/: system_M071Q_M071V.c
  group Library
    ../../../../Library/StdDriver/src/: clk.c retarget.c sc.c sys.c uart.c usbd.c
    ../../../../Library/SmartcardLib/: SmartCardLib_IAR.a
  group User
    ../: ccid.c Ccid_if.c descriptors.c main.c sc_intf.c
