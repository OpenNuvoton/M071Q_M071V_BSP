# Keil uVision project USBD_CCID.uvprojx, settings and files
target USBD_CCID (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: M071VG4AE Nuvoton
  pack: Nuvoton.NuMicro_DFP.1.3.9
  cpu: IRAM(0x20000000,0x2000) IROM(0x00000000,0x8000) CPUTYPE("Cortex-M0") CLOCK(12000000)
  output: USBD_CCID
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\..\..\..\Library\CMSIS\Include;..\..\..\..\Library\Device\Nuvoton\M071Q_M071V\Include;..\..\..\..\Library\StdDriver\inc;..\..\..\..\Library\SmartcardLib\Include
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x2000
  link misc: --map --first='startup_M071Q_M071V.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../../../../Library/Device/Nuvoton/M071Q_M071V/Source/: system_M071Q_M071V.c
    ../../../../Library/Device/Nuvoton/M071Q_M071V/Source/ARM/: startup_M071Q_M071V.s
  group User
    ../: main.c ccid.c Ccid_if.c descriptors.c sc_intf.c
  group Library
    ../../../../Library/StdDriver/src/: retarget.c clk.c sys.c uart.c sc.c usbd.c
    ../../../../Library/SmartcardLib/: SmartCardLib_Keil.lib
