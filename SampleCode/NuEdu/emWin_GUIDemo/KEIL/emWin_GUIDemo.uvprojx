# Keil uVision project emWin_GUIDemo.uvprojx, settings and files
target emWin_GUIDemo_ILI9341 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: M071QG4AE Nuvoton
  pack: Nuvoton.NuMicro_DFP.1.3.9
  cpu: IRAM(0x20000000,0x5000) IROM(0x00000000,0x40000) CPUTYPE("Cortex-M0") CLOCK(12000000)
  output: emWin_GUIDemo_ILI9341
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=3 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: __DEMO_320x240__
  c include: ..\..\..\..\Library\CMSIS\Include;..\..\..\..\Library\Device\Nuvoton\M071Q_M071V\Include;..\..\..\..\Library\StdDriver\inc;..\..\..\..\ThirdParty\emWin\Config;..\..\..\..\ThirdParty\emWin\Include;..\..\..\..\Library\NuEdu\emWin\tslib;..\..\..\..\Library\NuEdu\emWin\lcm
  asm define: Stack_Size=0x800
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x5000
  link misc: --map --first='startup_M071Q_M071V.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../../../../Library/Device/Nuvoton/M071Q_M071V/Source/: system_M071Q_M071V.c
    ../../../../Library/Device/Nuvoton/M071Q_M071V/Source/ARM/: startup_M071Q_M071V.s
  group User
    ../: main.c
  group Library
    ../../../../Library/StdDriver/src/: clk.c gpio.c retarget.c spi.c sys.c timer.c uart.c fmc.c adc.c
  group emWin
    ../../../../ThirdParty/emWin/Config/: GUI_X.c GUIConf.c GUIConf.h LCDConf.c LCDConf.h
    ../../../../ThirdParty/emWin/Lib/: NUemWin_CM0_Keil.lib
  group Application
    ../Application/: GUIDEMO.c GUIDEMO_AntialiasedText.c GUIDEMO_Automotive.c GUIDEMO_BarGraph.c GUIDEMO_Bitmap.c GUIDEMO_ColorBar.c GUIDEMO_Conf.c GUIDEMO_Cursor.c GUIDEMO_Fading.c GUIDEMO_Graph.c GUIDEMO_IconView.c GUIDEMO_ImageFlow.c GUIDEMO_Intro.c GUIDEMO_Listview.c GUIDEMO_RadialMenu.c GUIDEMO_Resource.c GUIDEMO_Skinning.c GUIDEMO_Speed.c GUIDEMO_Speedometer.c GUIDEMO_Start.c GUIDEMO_TransparentDialog.c GUIDEMO_Treeview.c GUIDEMO_VScreen.c GUIDEMO_WashingMachine.c GUIDEMO_ZoomAndRotate.c
  group tslib
    ../../../../Library/NuEdu/emWin/tslib/: fbutils.c TouchPanel.c testutils.c ts_calibrate.c nuvoton_logo.c nuvoton_qrcode.c
  group lcm
    ../../../../Library/NuEdu/emWin/lcm/: ILI9341.c ST7735.c
target emWin_GUIDemo_ST7735 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: M071QG4AE Nuvoton
  pack: Nuvoton.NuMicro_DFP.1.3.9
  cpu: as above
  output: emWin_GUIDemo_ST7735
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=3 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: __DEMO_160x128__
  c include: as above
  asm define: Stack_Size=0x800
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x5000
  link misc: as above
