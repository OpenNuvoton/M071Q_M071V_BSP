# IAR project emWin_GUIDemo.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: M071Q_V series Nuvoton M071Q/M071V series
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: __DEMO_320x240__
  ICCARM.CCDiagSuppress: Pa082
  ICCARM.CCIncludePath2: ..\..\..\..\Library\CMSIS\Include; ..\..\..\..\Library\Device\Nuvoton\M071Q_M071V\Include; ..\..\..\..\Library\StdDriver\inc; ..\..\..\..\ThirdParty\emWin\Config; ..\..\..\..\ThirdParty\emWin\Include; ..\..\..\..\Library\NuEdu\emWin\lcm; ..\..\..\..\Library\NuEdu\emWin\tslib
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: emWin_GUIDemo.bin
  ILINK.IlinkOutputFile: emWin_GUIDemo.out
  ILINK.IlinkIcfFile: emWin_GUIDemo.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
  group Application
    ../Application/: GUIDEMO.c GUIDEMO.h GUIDEMO_AntialiasedText.c GUIDEMO_Automotive.c GUIDEMO_BarGraph.c GUIDEMO_Bitmap.c GUIDEMO_ColorBar.c GUIDEMO_Conf.c GUIDEMO_Cursor.c GUIDEMO_Fading.c GUIDEMO_Graph.c GUIDEMO_IconView.c GUIDEMO_ImageFlow.c GUIDEMO_Intro.c GUIDEMO_Listview.c GUIDEMO_RadialMenu.c GUIDEMO_Resource.c GUIDEMO_Skinning.c GUIDEMO_Speed.c GUIDEMO_Speedometer.c GUIDEMO_Start.c GUIDEMO_TransparentDialog.c GUIDEMO_Treeview.c GUIDEMO_VScreen.c GUIDEMO_WashingMachine.c GUIDEMO_ZoomAndRotate.c
  group CMSIS
    ../../../../Library/Device/Nuvoton/M071Q_M071V/Source/IAR/: startup_M071Q_M071V.s
    ../../../../Library/Device/Nuvoton/M071Q_M071V/Source/: system_M071Q_M071V.c
  group emWin
    ../../../../ThirdParty/emWin/Config/: GUI_X.c GUIConf.c GUIConf.h LCDConf.c LCDConf.h
    ../../../../ThirdParty/emWin/Lib/: NUemWin_CM0_IAR.a
  group lcm
    ../../../../Library/NuEdu/emWin/lcm/: ILI9341.c lcm.h ST7735.c
  group Library
    ../../../../Library/StdDriver/src/: adc.c clk.c fmc.c gpio.c retarget.c spi.c sys.c timer.c uart.c
  group tslib
    ../../../../Library/NuEdu/emWin/tslib/: fbutils.c nuvoton_logo.c testutils.c TouchPanel.c ts_calibrate.c
  group User
    ../: main.c
