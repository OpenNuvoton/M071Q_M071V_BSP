# Keil uVision project ADC_PDMA_SingleCycleScanMode.uvprojx, settings and files
target ADC_PDMA_SingleCycleScanMode (6160000::V6.16::ARMCLANG)
  device: M071VG4AE Nuvoton
  pack: Nuvoton.NuMicro_DFP.1.3.9
  cpu: IRAM(0x20000000,0x5000) IROM(0x00000000,0x40000) CPUTYPE("Cortex-M0") CLOCK(12000000)
  output: ADC_PDMA_SingleCycleScanMode
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c include: ..\..\..\..\Library\CMSIS\Include;..\..\..\..\Library\StdDriver\inc;..\..\..\..\Library\Device\Nuvoton\M071Q_M071V\Include
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x5000
  link misc: --map --first='startup_M071Q_M071V.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../../../../Library/Device/Nuvoton/M071Q_M071V/Source/: system_M071Q_M071V.c
    ../../../../Library/Device/Nuvoton/M071Q_M071V/Source/ARM/: startup_M071Q_M071V.s
  group User
    ../: main.c
  group Library
    ../../../../Library/StdDriver/src/: retarget.c clk.c sys.c uart.c adc.c
