# IAR project I2C_Master_PDMA.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: M071Q_V series Nuvoton M071Q/M071V series
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDiagSuppress: Pa082
  ICCARM.CCIncludePath2: ..\..\..\..\Library\Device\Nuvoton\M071Q_M071V\Include; ..\..\..\..\Library\CMSIS\Include; ..\..\..\..\Library\StdDriver\inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: I2C_Master_PDMA.bin
  ILINK.IlinkOutputFile: I2C_Master_PDMA.out
  ILINK.IlinkIcfFile: I2C_Master_PDMA.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
  group CMSIS
    ../../../../Library/Device/Nuvoton/M071Q_M071V/Source/IAR/: startup_M071Q_M071V.s
    ../../../../Library/Device/Nuvoton/M071Q_M071V/Source/: system_M071Q_M071V.c
  group Library
    ../../../../Library/StdDriver/src/: clk.c i2c.c pdma.c retarget.c sys.c uart.c
  group User
    ../: main.c
