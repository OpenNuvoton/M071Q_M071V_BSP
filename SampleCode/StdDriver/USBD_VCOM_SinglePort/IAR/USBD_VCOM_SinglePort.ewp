# IAR project USBD_VCOM_SinglePort.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: M071Q_V series Nuvoton M071Q/M071V series
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDiagSuppress: Pa082
  ICCARM.CCIncludePath2: $PROJ_DIR$; ..\..\..\..\Library\CMSIS\Include; ..\..\..\..\Library\Device\Nuvoton\M071Q_M071V\Include; ..\..\..\..\Library\StdDriver\inc
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: USBD_VCOM_SinglePort.bin
  ILINK.IlinkOutputFile: USBD_VCOM_SinglePort.out
  ILINK.IlinkIcfFile: USBD_VCOM_SinglePort.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
  group CMSIS
    ../../../../Library/Device/Nuvoton/M071Q_M071V/Source/IAR/: startup_M071Q_M071V.s
    ../../../../Library/Device/Nuvoton/M071Q_M071V/Source/: system_M071Q_M071V.c
  group Library
    ../../../../Library/StdDriver/src/: clk.c fmc.c retarget.c sys.c usbd.c
  group User
    ../: cdc_serial.c descriptors.c main.c
