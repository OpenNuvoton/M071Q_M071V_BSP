# IAR project FMC_IAP.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: M071Q_V series Nuvoton M071Q/M071V series
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDiagSuppress: Pa082
  ICCARM.CCIncludePath2: ..\..\..\..\Library\CMSIS\Include; ..\..\..\..\Library\Device\Nuvoton\M071Q_M071V\Include; ..\..\..\..\Library\StdDriver\inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: $PROJ_DIR$
  OBJCOPY.OOCOutputFile: FMC_IAP.bin
  ILINK.IlinkOutputFile: FMC_IAP.out
  ILINK.IlinkIcfFile: FMC.icf
  ILINK.IlinkExtraOptions: --image_input Release\Exe\FMC_IAP_LD.bin,loaderImageBase,.bin_image,4; --image_input dummy.bin,loaderImageLimit,.bin_image,4
  ILINK.IlinkProgramEntryLabel: Reset_Handler
  group CMSIS
    ../../../../Library/Device/Nuvoton/M071Q_M071V/Source/IAR/: startup_M071Q_M071V.s
    ../../../../Library/Device/Nuvoton/M071Q_M071V/Source/: system_M071Q_M071V.c
  group Library
    ../../../../Library/StdDriver/src/: retarget.c
  group User
    ../: main.c
